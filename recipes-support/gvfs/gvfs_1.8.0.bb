require gvfs.inc

PR = "r0"

SRC_URI = "http://ftp.gnome.org/pub/gnome/sources/gvfs/1.8/${PN}-${PV}.tar.bz2"
S = "${WORKDIR}/${PN}-${PV}"

