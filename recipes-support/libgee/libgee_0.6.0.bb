require libgee.inc
PE = "1"
PR = "r4"

SRC_URI = "http://ftp.gnome.org/pub/GNOME/sources/libgee/0.6/${BPN}-${PV}.tar.bz2"
S = "${WORKDIR}/${BPN}-${PV}"
