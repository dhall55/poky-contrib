FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI += "file://inherit-gnome-icon-theme.patch"
