SRCREV=${AUTOREV}
# BB_LOCALCOUNT_OVERRIDE = "1"
LOCALCOUNT = "0"

# For local kern-tools work, fill in KERN_TOOLS_SRC and uncomment the SRC_URI
# KERN_TOOLS_SRC ?= /path/to/local/kern-tools-clone
# SRC_URI = "git://${KERN_TOOLS_SRC}"
