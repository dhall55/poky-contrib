require make_${PV}.bb

inherit native

BPN = "make"
EXTRAINSTALL = ""
