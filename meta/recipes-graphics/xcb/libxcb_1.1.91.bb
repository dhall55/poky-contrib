include libxcb.inc
PR = "r3"

DEPENDS += "libpthread-stubs xcb-proto-native"

PACKAGES =+ "libxcb-xinerama"
