DEPENDS += "faac faad2"

EXTRA_OECONF += "--with-plugins=faac,faad"
