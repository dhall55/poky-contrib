#
# Copyright (C) 2011 Intel Corporation.
#
require recipes-sato/images/core-image-sato.bb

IMAGE_INSTALL += "sun-jse-jre"

LICENSE = "MIT"

PR = "r0"
